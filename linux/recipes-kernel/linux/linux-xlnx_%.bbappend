SRC_URI += "file://axieth.patch \
            file://user.cfg \
            file://user_2020-03-06-13-31-00.cfg \
            file://user_2020-03-26-14-00-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

